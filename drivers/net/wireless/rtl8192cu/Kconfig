## drivers/net/wireless/rtl8192cu/Kconfig
```kconfig
config RTL8192CU
	boolean "Realtek 8192C USB WiFi"
	depends on USB
	select GENERIC_KERNEL_THREAD
	---help---
	  Help message of RTL8192CU
```
